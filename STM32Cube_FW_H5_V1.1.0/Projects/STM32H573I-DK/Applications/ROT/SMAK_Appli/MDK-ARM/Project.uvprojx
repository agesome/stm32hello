# Keil uVision project Project.uvprojx, settings and files
target STM32H573I-DK_SMAK_Appli (6180000::V6.18::ARMCLANG)
  device: STM32H573IIKx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.0.0
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  BeforeMake: ..\prebuild.bat
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\appli.bin"
  AfterMake: postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H573xx,USE_HAL_DRIVER,USE_NUCLEO_144_NO,TFM_PSA_API
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/secure_manager_api/ipc/nonsecure/inc;../../../../../../Middlewares/ST/secure_manager_api/interface/inc
  library: MicroLIB
  scatter file: stm32h5xx_app.sct
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx_ns.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32h573xx.s
  group Application/User
    ../Src/: com.c common.c cryp.c crypto_tests_common.c eat.c fwu.c its.c main.c stm32h5xx_hal_msp.c stm32h5xx_it.c ymodem.c
  group Middlewares/SecureManager
    ../../../../../../Middlewares/ST/secure_manager_api/interface/src/: check_parameters.c psa_fwu.c psa_ia.c psa_its.c tfm_crypto_secure_api.c
    ../../../../../../Middlewares/ST/secure_manager_api/ipc/nonsecure/src/: psa_client.c tfm_ns_interface.c
software components: CMSIS:CORE 4.3.0
