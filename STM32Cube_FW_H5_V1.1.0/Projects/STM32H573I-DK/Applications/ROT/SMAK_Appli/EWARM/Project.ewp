# IAR project Project.ewp, settings and files
configuration STM32H573I-DK_SMAK_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H573II ST STM32H573II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32H573xx; USE_HAL_DRIVER; USE_NUCLEO_144_NO; TFM_PSA_API
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include; ..\..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\secure_manager_api\ipc\nonsecure\inc; ..\..\..\..\..\..\Middlewares\ST\secure_manager_api\interface\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\..\Binary\appli.bin
  prebuild: cmd /C ..\prebuild.bat
  postbuild: cmd /C postbuild.bat "$PROJ_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h573xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx_ns.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c
  group Example/EWARM
    ./: startup_stm32h573xx.s
  group Example/User
    ../Src/: com.c common.c cryp.c crypto_tests_common.c eat.c fwu.c its.c main.c stm32h5xx_hal_msp.c stm32h5xx_it.c ymodem.c
  group Middlewares/SecureManager
    ../../../../../../Middlewares/ST/secure_manager_api/interface/src/: check_parameters.c psa_fwu.c psa_ia.c psa_its.c tfm_crypto_secure_api.c
    ../../../../../../Middlewares/ST/secure_manager_api/ipc/nonsecure/src/: psa_client.c tfm_ns_interface.c
